#include "App_FaultHandler.h"
#include "App_Motor_Project.h"  // 包含 ID_VOLTAGE_BUS, ID_MOTOR 等设备ID定义
#include "EventBus.h"
#include "App_Params.h"
#include "dev_voltage.h"
#include "dev_motor.h"
#include "dev_sensor.h"
#include "device_manager.h"
#include "rtt_manager.h"
#include "rtt_log.h"
#include "App_RunAngle.h"
#include "App_MotionTimeout.h"

/*=============================================================================
 * 调试宏定义
 * 开关在 rtt_manager.h 中统一管理：APP_FAULT_HANDLER_DBG
 *============================================================================*/
#ifdef APP_FAULT_HANDLER_DBG
    #define FAULT_DBG(fmt, ...)    MAIN_D("[FAULT] " fmt, ##__VA_ARGS__)
#else
    #define FAULT_DBG(fmt, ...)    ((void)0)
#endif

/*=============================================================================
 * 电压告警事件回调函数
 *============================================================================*/
static void FaultHandler_OnVoltageAlarm(void* payload)
{
    Voltage_AlarmEvent_t* pEvent = (Voltage_AlarmEvent_t*)payload;
    
    if (pEvent == NULL)
    {
        return;
    }
    
    switch (pEvent->u8AlarmType)
    {
    case VOLTAGE_ALARM_OVERVOLTAGE:
        if (pEvent->u8IsActive)
        {
            RealTime_SetFault(FAULT_BIT_OVERVOLTAGE);
            FAULT_DBG("Overvoltage triggered, set fault bit0, mV=%lu, threshold=%lu", 
                      (unsigned long)pEvent->u32BusVoltageMv, 
                      (unsigned long)pEvent->u32ThresholdMv);
        }
        else
        {
            RealTime_ClearFault(FAULT_BIT_OVERVOLTAGE);
            FAULT_DBG("Overvoltage released, clear fault bit0, mV=%lu, threshold=%lu", 
                      (unsigned long)pEvent->u32BusVoltageMv, 
                      (unsigned long)pEvent->u32ThresholdMv);
        }
        break;
        
    case VOLTAGE_ALARM_UNDERVOLTAGE:
        if (pEvent->u8IsActive)
        {
            RealTime_SetFault(FAULT_BIT_UNDERVOLTAGE);
            /* Save absolute angle position to Flash before power loss */
            RunAngle_Cmd(ABS_CMD_SAVE);
            FAULT_DBG("Undervoltage triggered, set fault bit6, mV=%lu, threshold=%lu",
                      (unsigned long)pEvent->u32BusVoltageMv, 
                      (unsigned long)pEvent->u32ThresholdMv);
        }
        else
        {
            RealTime_ClearFault(FAULT_BIT_UNDERVOLTAGE);
            FAULT_DBG("Undervoltage released, clear fault bit6, mV=%lu, threshold=%lu", 
                      (unsigned long)pEvent->u32BusVoltageMv, 
                      (unsigned long)pEvent->u32ThresholdMv);
        }
        break;
        
    default:
        FAULT_DBG("Unknown alarm type: %d", (int)pEvent->u8AlarmType);
        break;
    }
}

/*=============================================================================
 * 电流告警事件回调函数
 *
 * 注意：反转堵转属于预期工况（如阀门关闭到位），不报过流故障码。
 *       过流故障已拆分为FAULT_BIT_OVERCURRENT_FWD(正转)和FAULT_BIT_OVERCURRENT_REV(反转)。
 *============================================================================*/
static void FaultHandler_OnCurrentAlarm(void* payload)
{
    Current_AlarmEvent_t* pEvent = (Current_AlarmEvent_t*)payload;
    
    if (pEvent == NULL)
    {
        return;
    }
    
    if (pEvent->u8IsActive)
    {
        /* 判断当前电机方向：仅正转时过流才报故障码 */
        MotorDir_t eDesiredDir = DIR_NONE;
        
        DeviceNode_t* pstcMotorNode = DeviceManager_Get(ID_MOTOR);
        if (pstcMotorNode != NULL && pstcMotorNode->private_data != NULL)
        {
            MotorDevice_t* pstcMotorDev = (MotorDevice_t*)pstcMotorNode->private_data;
            eDesiredDir = Motor_GetDesiredDirection(pstcMotorDev);
        }
        
        if (eDesiredDir == DIR_FWD)
        {
            /* 正转时过流 → 报故障码 */
            RealTime_SetFault(FAULT_BIT_OVERCURRENT_FWD);
            FAULT_DBG("Overcurrent triggered (FWD), set fault bit, mA=%ld, threshold=%ld",
                      (long)pEvent->s32CurrentMa,
                      (long)pEvent->s32ThresholdMa);
        }
        else
        {
            /* 反转或停止时过流 → 不报故障码（反转堵转属于预期工况） */
            FAULT_DBG("Overcurrent triggered (dir=%d, REV/STOP is normal stall), skip fault bit, mA=%ld, threshold=%ld",
                      (int)eDesiredDir,
                      (long)pEvent->s32CurrentMa,
                      (long)pEvent->s32ThresholdMa);
        }
    }
    else
    {
        RealTime_ClearFault(FAULT_BIT_OVERCURRENT_FWD | FAULT_BIT_OVERCURRENT_REV);
        FAULT_DBG("Overcurrent released, clear fault bit, mA=%ld, threshold=%ld",
                  (long)pEvent->s32CurrentMa,
                  (long)pEvent->s32ThresholdMa);
    }
}

/*=============================================================================
 * 初始化函数
 *============================================================================*/
void FaultHandler_Init(void)
{
    /* 订阅电压告警事件 */
    EventBus_Subscribe(TOPIC_VOLTAGE_ALARM, FaultHandler_OnVoltageAlarm, 1);
    
    /* 订阅电流告警事件 */
    EventBus_Subscribe(TOPIC_CURRENT_ALARM, FaultHandler_OnCurrentAlarm, 0);
    
    FAULT_DBG("FaultHandler initialized, subscribed to TOPIC_VOLTAGE_ALARM and TOPIC_CURRENT_ALARM");
}

/*=============================================================================
 * 故障清除回调 - 由 Modbus 写 REG_FAULT_STATUS 触发
 *============================================================================*/
void FaultHandler_ClearFault(uint8_t u8FaultType)
{
    FAULT_DBG("ClearFault: type=%d\r\n", (int)u8FaultType);
    
    // 获取电压设备指针（ID_VOLTAGE_BUS 在 App_Motor_Project.h 中定义为13）
    DeviceNode_t* pstcVoltageNode = DeviceManager_Get(ID_VOLTAGE_BUS);
    if (pstcVoltageNode == NULL || pstcVoltageNode->private_data == NULL) {
        FAULT_DBG("ClearFault: Voltage device not found!\r\n");
        return;
    }
    Voltage_Device_t* pstcVoltageDev = (Voltage_Device_t*)pstcVoltageNode->private_data;
    
    // 获取电机设备指针（ID_MOTOR 在 App_Motor_Project.h 中定义为0）
    DeviceNode_t* pstcMotorNode = DeviceManager_Get(ID_MOTOR);
    if (pstcMotorNode == NULL || pstcMotorNode->private_data == NULL) {
        FAULT_DBG("ClearFault: Motor device not found!\r\n");
        return;
    }
    MotorDevice_t* pstcMotorDev = (MotorDevice_t*)pstcMotorNode->private_data;
    
    switch (u8FaultType)
    {
    case FAULT_TYPE_OVERVOLTAGE:
        // 1. 清除电压告警状态（会发布解除事件）
        Voltage_Device_ClearAlarm(pstcVoltageDev, VOLTAGE_ALARM_OVERVOLTAGE);
        // 2. 清除电机仲裁器中的过压 block 指令
        Motor_ClearVoltageBlock(pstcMotorDev, VOLTAGE_ALARM_OVERVOLTAGE);
        // 3. 清除故障寄存器位
        RealTime_ClearFault(FAULT_BIT_OVERVOLTAGE);
        FAULT_DBG("ClearFault: Overvoltage cleared\r\n");
        break;
        
    case FAULT_TYPE_UNDERVOLTAGE:
        // 1. 清除电压告警状态（会发布解除事件）
        Voltage_Device_ClearAlarm(pstcVoltageDev, VOLTAGE_ALARM_UNDERVOLTAGE);
        // 2. 清除电机仲裁器中的欠压 block 指令
        Motor_ClearVoltageBlock(pstcMotorDev, VOLTAGE_ALARM_UNDERVOLTAGE);
        // 3. 清除故障寄存器位
        RealTime_ClearFault(FAULT_BIT_UNDERVOLTAGE);
        FAULT_DBG("ClearFault: Undervoltage cleared\r\n");
        break;
        
    case FAULT_TYPE_OVERCURRENT:
        {
            // 获取电流传感器设备指针（ID_SENSOR_CURRENT 在 App_Motor_Project.h 中定义为14）
            DeviceNode_t* pstcSensorNode = DeviceManager_Get(ID_SENSOR_CURRENT);
            if (pstcSensorNode == NULL || pstcSensorNode->private_data == NULL) {
                FAULT_DBG("ClearFault: Current sensor device not found!\r\n");
                return;
            }
            Sensor_Device_t* pstcSensorDev = (Sensor_Device_t*)pstcSensorNode->private_data;
            
            // 1. 清除传感器告警状态（会发布解除事件，触发 Motor_OnCurrentAlarm() 移除 block_fwd）
            Sensor_Device_ClearAlarm(pstcSensorDev);
            // 2. 清除电机仲裁器中的过流 block 指令（双重保险）
            Motor_ClearOvercurrentBlock(pstcMotorDev);
            // 3. 清除故障寄存器位
            RealTime_ClearFault(FAULT_BIT_OVERCURRENT_FWD | FAULT_BIT_OVERCURRENT_REV);
            FAULT_DBG("ClearFault: Overcurrent cleared\r\n");
        }
        break;

    case FAULT_TYPE_TIMEOUT:
        // 1. 取消当前超时检测
        MotionTimeout_Cancel();
        // 2. 移除电机仲裁器中的双向超时 block 指令，解除锁定
        Motor_ClearMotionTimeoutBlock(pstcMotorDev);
        // 3. 清除故障寄存器位 bit7
        RealTime_ClearFault(FAULT_BIT_MOTION_TIMEOUT);
        FAULT_DBG("ClearFault: Motion timeout cleared\r\n");
        break;

    default:
        FAULT_DBG("ClearFault: Unknown fault type=%d\r\n", (int)u8FaultType);
        break;
    }
            {
                Current_AlarmEvent_t stcReleaseEvent;
                stcReleaseEvent.s32CurrentMa = 0;
                stcReleaseEvent.s32ThresholdMa = 0;
                stcReleaseEvent.u8IsActive = 0;
                EventBus_Publish(TOPIC_OVERCURRENT_FWD, &stcReleaseEvent);
                EventBus_Publish(TOPIC_OVERCURRENT_REV, &stcReleaseEvent);
            }
}
